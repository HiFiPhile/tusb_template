# IAR project TUSB_Test.ewp, settings and files
configuration TUSB_STM32G0 (ARM, debug)
  General.OGChipSelectEditMenu: STM32G0B1RE ST STM32G0B1RE
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: STM32G0B1xx; CFG_TUSB_MCU=OPT_MCU_STM32G0; CFG_TUSB_DEBUG=2; LOGGER_RTT
  ICCARM.CCIncludePath2: ..; ..\tinyusb/src; ..\tinyusb\lib\SEGGER_RTT\RTT; ..\tinyusb\lib\SEGGER_RTT\Config; $PROJ_DIR$; ..\tinyusb/hw; ..\tinyusb\lib\CMSIS_5\CMSIS\Core\Include; ..\tinyusb\examples\device\hid_generic_inout\src; ..\tinyusb\hw\mcu\st\cmsis_device_g0\Include; ..\tinyusb\hw\mcu\st\stm32g0xx_hal_driver\Inc; ..\tinyusb\hw\bsp; ..\tinyusb\hw\bsp\stm32g0\boards\stm32g0b1nucleo; ..\tinyusb\hw\bsp\stm32g0
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: TUSB_STM32G0.bin
  ILINK.IlinkOutputFile: TUSB_Test.out
  ILINK.IlinkIcfFile: ..\tinyusb\hw\mcu\st\cmsis_device_g0\Source\Templates\iar\linker\stm32g0b1xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration TUSB_LPC55 (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: LPC55S69_core0 NXP LPC55S69_core0
  General.CoreVariant: 61
  General.FPU2: 6
  ICCARM.CCDefines: CPU_LPC55S69JBD100_cm33_core0; CFG_TUSB_MCU=OPT_MCU_LPC55; CFG_TUSB_DEBUG=0; LOGGER_RTT; BOARD_TUD_MAX_SPEED=OPT_MODE_HIGH_SPEED; BOARD_TUD_RHPORT=1; CFG_TUSB_MEM_SECTION=__attribute__((section("m_usb_global"))); CFG_TUSB_MEM_ALIGN=__attribute__((aligned(64)))
  ICCARM.CCIncludePath2: ..; ..\tinyusb/src; ..\tinyusb\lib\SEGGER_RTT\RTT; ..\tinyusb\lib\SEGGER_RTT\Config; $PROJ_DIR$; ..\tinyusb/hw; ..\tinyusb\examples\device\uac2_headset\src; ..\tinyusb\hw\mcu\nxp\mcux-sdk\devices\LPC55S69; ..\tinyusb\hw\bsp\lpc55\boards\lpcxpresso55s69; ..\tinyusb\lib\CMSIS_5\CMSIS\Core\Include; ..\tinyusb\hw\mcu\nxp\mcux-sdk\drivers; ..\tinyusb\hw\mcu\nxp\mcux-sdk\drivers\common; ..\tinyusb\hw\mcu\nxp\mcux-sdk\drivers\lpc_gpio; ..\tinyusb\hw\mcu\nxp\mcux-sdk\drivers\lpc_iocon; ..\tinyusb\hw\mcu\nxp\mcux-sdk\drivers\flexcomm; ..\tinyusb\hw\mcu\nxp\mcux-sdk\drivers\sctimer; ..\tinyusb\hw\mcu\nxp\mcux-sdk\devices\LPC55S69\drivers
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 1
  ILINK.IlinkIcfFile: LPC55S69_cm33_core0_flash.icf
configuration TUSB_STM32F429_HSnoPhy (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: STM32F429IG ST STM32F429IG
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: STM32F429xx; CFG_TUSB_MCU=OPT_MCU_STM32F4; CFG_TUSB_DEBUG=1; LOGGER_RTT; BOARD_TUD_RHPORT=1; HSE_VALUE=25000000; TUD_AUDIO_PREFER_RING_BUFFER=0; CMB_CPU_PLATFORM_TYPE=CMB_CPU_ARM_CORTEX_M4
  ICCARM.CCIncludePath2: ..; ..\tinyusb/src; ..\tinyusb\lib\SEGGER_RTT\RTT; ..\tinyusb\lib\SEGGER_RTT\Config; $PROJ_DIR$; ..\tinyusb/hw; ..\tinyusb\lib\CMSIS_5\CMSIS\Core\Include; ..\tinyusb\examples\device\audio_4_channel_mic\src; ..\tinyusb\hw\mcu\st\cmsis_device_f4\Include; ..\tinyusb\hw\mcu\st\stm32f4xx_hal_driver\Inc; ..\stm32f4x9-dk-a; ..\tinyusb\hw\bsp\stm32f4
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 1
  OBJCOPY.OOCOutputFile: TUSB_Test.bin
  ILINK.IlinkIcfFile: ..\tinyusb\hw\mcu\st\cmsis_device_f4\Source\Templates\iar\linker\stm32f429xx_flash.icf
configuration TUSB_STM32F4-DISCO (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: STM32F407VG ST STM32F407VG
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: STM32F407xx; CFG_TUSB_MCU=OPT_MCU_STM32F4; CFG_TUSB_DEBUG=0; LOGGER_RTT; BOARD_TUD_RHPORT=1; CMB_CPU_PLATFORM_TYPE=CMB_CPU_ARM_CORTEX_M4; TUD_AUDIO_PREFER_RING_BUFFER=0
  ICCARM.CCIncludePath2: ..; ..\tinyusb/src; ..\tinyusb\lib\SEGGER_RTT\RTT; ..\tinyusb\lib\SEGGER_RTT\Config; $PROJ_DIR$; ..\tinyusb/hw; ..\tinyusb\lib\CMSIS_5\CMSIS\Core\Include; ..\tinyusb\hw\mcu\st\cmsis_device_f4\Include; ..\tinyusb\hw\mcu\st\stm32f4xx_hal_driver\Inc; ..\tinyusb\hw\bsp\stm32f4; ..\stm32f407-disco; ..\tinyusb\examples\device\audio_4_channel_mic\src; ..\tinyusb/lib/lwip/src/include; ..\tinyusb/lib/lwip/src/include/ipv4; ..\tinyusb/lib/lwip/src/include/lwip/apps; ..\tinyusb/lib/networking
  ICCARM.CCOptLevel: 2
  ICCARM.CCOptStrategy: 1
  OBJCOPY.OOCOutputFile: TUSB_Test.bin
  ILINK.IlinkIcfFile: ..\tinyusb\hw\mcu\st\cmsis_device_f4\Source\Templates\iar\linker\stm32f407xx_flash.icf
configuration TUSB_STM32L0 (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: STM32L053C8 ST STM32L053C8
  ICCARM.CCDefines: STM32L053xx; CFG_TUSB_MCU=OPT_MCU_STM32L0; CFG_TUSB_DEBUG=0; LOGGER_RTT; CFG_EXAMPLE_VIDEO_READONLY
  ICCARM.CCIncludePath2: ..; ..\tinyusb/src; ..\tinyusb\lib\SEGGER_RTT\RTT; ..\tinyusb\lib\SEGGER_RTT\Config; $PROJ_DIR$; ..\tinyusb/hw; ..\tinyusb\lib\CMSIS_5\CMSIS\Core\Include; ..\tinyusb\examples\device\video_capture\src; ..\tinyusb\hw\mcu\st\cmsis_device_l0\Include; ..\tinyusb\hw\mcu\st\stm32l0xx_hal_driver\Inc; ..\tinyusb\hw\bsp; ..\tinyusb\hw\bsp\stm32l0\boards\stm32l0538disco; ..\tinyusb\hw\bsp\stm32l0
  ICCARM.CCOptLevel: 2
  ICCARM.CCOptStrategy: 0
  OBJCOPY.OOCOutputFile: TUSB_Test.bin
  ILINK.IlinkIcfFile: ..\tinyusb\hw\mcu\st\cmsis_device_l0\Source\Templates\iar\linker\stm32l053xx_flash.icf
configuration TUSB_STM32H5 (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: STM32H573I-DK ST STM32H573I-DK
  General.CoreVariant: 61
  General.FPU2: 6
  ICCARM.CCDefines: STM32H573xx; CFG_TUSB_MCU=OPT_MCU_STM32H5; CFG_TUSB_DEBUG=0; LOGGER_RTT
  ICCARM.CCIncludePath2: ..; ..\tinyusb/src; ..\tinyusb\lib\SEGGER_RTT\RTT; ..\tinyusb\lib\SEGGER_RTT\Config; $PROJ_DIR$; ..\tinyusb/hw; ..\tinyusb\lib\CMSIS_5\CMSIS\Core\Include; ..\tinyusb\examples\device\uac2_headset\src; ..\tinyusb\hw\mcu\st\cmsis_device_h5\Include; ..\tinyusb\hw\mcu\st\stm32h5xx_hal_driver\Inc; ..\tinyusb\hw\bsp; ..\tinyusb\hw\bsp\stm32h5\boards\stm32h573i_dk; ..\tinyusb\hw\bsp\stm32h5
  ICCARM.CCOptLevel: 2
  OBJCOPY.OOCOutputFile: TUSB_Test.bin
configuration TUSB_STM32F723E-DISCO (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: STM32F723IE ST STM32F723IE
  General.CoreVariant: 41
  General.FPU2: 6
  ICCARM.CCDefines: STM32F723xx; CFG_TUSB_MCU=OPT_MCU_STM32F7; CFG_TUSB_DEBUG=0; LOGGER_RTT; BOARD_TUD_RHPORT=1; HSE_VALUE=25000000; CMB_CPU_PLATFORM_TYPE=CMB_CPU_ARM_CORTEX_M7; TUD_AUDIO_PREFER_RING_BUFFER=0; BUFFER_SIZE_UP=4096
  ICCARM.CCIncludePath2: ..; ..\tinyusb/src; ..\stm32f723e-disco; ..\tinyusb\lib\SEGGER_RTT\RTT; ..\tinyusb\lib\SEGGER_RTT\Config; $PROJ_DIR$; ..\tinyusb/hw; ..\tinyusb\lib\CMSIS_5\CMSIS\Core\Include; ..\tinyusb\hw\mcu\st\cmsis_device_f7\Include; ..\tinyusb\hw\mcu\st\stm32f7xx_hal_driver\Inc; ..\tinyusb\hw\bsp\stm32f7; ..\tinyusb\hw\bsp\stm32f7\boards\stm32f723disco; ..\tinyusb\examples\device\cdc_dual_ports\src; ..\tinyusb/lib/lwip/src/include; ..\tinyusb/lib/lwip/src/include/ipv4; ..\tinyusb/lib/lwip/src/include/lwip/apps; ..\tinyusb/lib/networking
  ICCARM.CCOptStrategy: 0
  OBJCOPY.OOCOutputFile: TUSB_Test.bin
  ILINK.IlinkIcfFile: ..\tinyusb\hw\mcu\st\cmsis_device_f7\Source\Templates\iar\linker\stm32f723xx_flash.icf
configuration TUSB_NUCLEO-U5A5 (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: STM32U5A5ZJ ST STM32U5A5ZJ
  General.CoreVariant: 61
  General.FPU2: 6
  ICCARM.CCDefines: STM32U5A5xx; CFG_TUSB_MCU=OPT_MCU_STM32U5; CFG_TUSB_DEBUG=0; LOGGER_RTT; CMB_CPU_PLATFORM_TYPE=CMB_CPU_ARM_CORTEX_M7; TUD_AUDIO_PREFER_RING_BUFFER=0; BUFFER_SIZE_UP=16384
  ICCARM.CCIncludePath2: ..; ..\tinyusb/src; ..\tinyusb\lib\SEGGER_RTT\RTT; ..\tinyusb\lib\SEGGER_RTT\Config; $PROJ_DIR$; ..\tinyusb/hw; ..\tinyusb\lib\CMSIS_5\CMSIS\Core\Include; ..\tinyusb\hw\mcu\st\cmsis_device_u5\Include; ..\tinyusb\hw\mcu\st\stm32u5xx_hal_driver\Inc; ..\tinyusb\hw\bsp\stm32u5; ..\tinyusb\hw\bsp\stm32u5\boards\stm32u5a5nucleo; ..\tinyusb\examples\device\uac2_speaker_fb\src
  ICCARM.CCOptLevel: 2
  ICCARM.CCOptStrategy: 0
  OBJCOPY.OOCOutputFile: TUSB_Test.bin
  ILINK.IlinkIcfFile: ..\tinyusb\hw\mcu\st\cmsis_device_u5\Source\Templates\iar\linker\stm32u5a5xx_flash.icf
configuration TUSB_STM32F723E-DISCO_FS (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: STM32F723IE ST STM32F723IE
  General.CoreVariant: 41
  General.FPU2: 6
  ICCARM.CCDefines: STM32F723xx; CFG_TUSB_MCU=OPT_MCU_STM32F7; CFG_TUSB_DEBUG=0; LOGGER_RTT; BOARD_TUD_RHPORT=0; BOARD_TUD_MAX_SPEED=OPT_MODE_FULL_SPEED; HSE_VALUE=25000000; CMB_CPU_PLATFORM_TYPE=CMB_CPU_ARM_CORTEX_M7; TUD_AUDIO_PREFER_RING_BUFFER=0; BUFFER_SIZE_UP=1024
  ICCARM.CCIncludePath2: as above
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  OBJCOPY.OOCOutputFile: TUSB_Test.bin
  ILINK.IlinkIcfFile: as above
configuration TUSB_MIMXRT1170-EVKB (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: MIMXRT1176xxxA_M7 NXP MIMXRT1176xxxA_M7
  General.CoreVariant: 41
  General.FPU2: 7
  ICCARM.CCDefines: CPU_MIMXRT1176DVMAA_cm7; CFG_TUSB_MCU=OPT_MCU_MIMXRT1XXX; CFG_TUSB_DEBUG=0; LOGGER_RTT; BOARD_TUD_MAX_SPEED=OPT_MODE_HIGH_SPEED; BOARD_TUD_RHPORT=0; XIP_EXTERNAL_FLASH=1; XIP_BOOT_HEADER_ENABLE=1
  ICCARM.CCIncludePath2: ..; ..\tinyusb/src; ..\tinyusb\lib\SEGGER_RTT\RTT; ..\tinyusb\lib\SEGGER_RTT\Config; $PROJ_DIR$; ..\tinyusb/hw; ..\tinyusb\examples\device\uac2_headset\src; ..\tinyusb\hw\mcu\nxp\mcux-sdk\devices\MIMXRT1176; ..\tinyusb\hw\bsp\imxrt\boards\mimxrt1170_evkb; ..\tinyusb\lib\CMSIS_5\CMSIS\Core\Include; ..\tinyusb\hw\mcu\nxp\mcux-sdk\drivers; ..\tinyusb\hw\mcu\nxp\mcux-sdk\drivers\common; ..\tinyusb\hw\mcu\nxp\mcux-sdk\drivers\igpio; ..\tinyusb\hw\mcu\nxp\mcux-sdk\drivers\lpuart; ..\tinyusb\hw\mcu\nxp\mcux-sdk\drivers\ocotp; ..\tinyusb\hw\mcu\nxp\mcux-sdk\devices\MIMXRT1176\drivers
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 1
  ILINK.IlinkIcfFile: ..\mimxrt1170-evkb\MIMXRT1176xxxxx_cm7_flexspi_nor.icf
  group drv_f4
    ../tinyusb/hw/bsp/stm32f4/: family.c
    ../tinyusb/hw/mcu/st/cmsis_device_f4/Source/Templates/iar/: startup_stm32f407xx.s startup_stm32f429xx.s
    ../tinyusb/hw/mcu/st/cmsis_device_f4/Source/Templates/iar/linker/: stm32f407xx_flash.icf stm32f429xx_flash.icf
    ../tinyusb/hw/mcu/st/stm32f4xx_hal_driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_cortex.c stm32f4xx_hal_gpio.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_uart.c
    ../tinyusb/hw/mcu/st/cmsis_device_f4/Source/Templates/: system_stm32f4xx.c
  group drv_f7
    ../tinyusb/hw/bsp/stm32f7/: family.c
    ../stm32f723e-disco/: main_audio.c
    ../tinyusb/hw/mcu/st/cmsis_device_f7/Source/Templates/iar/: startup_stm32f723xx.s
    ../tinyusb/hw/mcu/st/cmsis_device_f7/Source/Templates/iar/linker/: stm32f723xx_flash.icf
    ../tinyusb/hw/mcu/st/stm32f7xx_hal_driver/Src/: stm32f7xx_hal.c stm32f7xx_hal_cortex.c stm32f7xx_hal_dma.c stm32f7xx_hal_gpio.c stm32f7xx_hal_i2c.c stm32f7xx_hal_pwr.c stm32f7xx_hal_pwr_ex.c stm32f7xx_hal_rcc.c stm32f7xx_hal_rcc_ex.c stm32f7xx_hal_sai.c stm32f7xx_hal_uart.c
    ../tinyusb/hw/mcu/st/cmsis_device_f7/Source/Templates/: system_stm32f7xx.c
  group drv_f7/BSP
    ../stm32f723e-disco/: stm32f723e_discovery.c stm32f723e_discovery.h stm32f723e_discovery_audio.c stm32f723e_discovery_audio.h wm8994.c wm8994.h
  group drv_g0
    ../tinyusb/hw/bsp/stm32g0/: family.c
    ../tinyusb/hw/mcu/st/cmsis_device_g0/Source/Templates/iar/: startup_stm32g0b1xx.s
    ../tinyusb/hw/mcu/st/cmsis_device_g0/Source/Templates/iar/linker/: stm32g0b1xx_flash.icf
    ../tinyusb/hw/mcu/st/stm32g0xx_hal_driver/Src/: stm32g0xx_hal.c stm32g0xx_hal_cortex.c stm32g0xx_hal_gpio.c stm32g0xx_hal_pwr.c stm32g0xx_hal_pwr_ex.c stm32g0xx_hal_rcc.c stm32g0xx_hal_rcc_ex.c stm32g0xx_hal_uart.c
    ../tinyusb/hw/mcu/st/cmsis_device_g0/Source/Templates/: system_stm32g0xx.c
  group drv_h5
    ../tinyusb/hw/bsp/stm32h5/: family.c
    ../tinyusb/hw/mcu/st/cmsis_device_h5/Source/Templates/iar/: startup_stm32h573xx.s
    ../tinyusb/hw/mcu/st/cmsis_device_h5/Source/Templates/iar/linker/: stm32h573xx_flash.icf
    ../tinyusb/hw/mcu/st/stm32h5xx_hal_driver/Src/: stm32h5xx_hal.c stm32h5xx_hal_cortex.c stm32h5xx_hal_gpio.c stm32h5xx_hal_pwr.c stm32h5xx_hal_pwr_ex.c stm32h5xx_hal_rcc.c stm32h5xx_hal_rcc_ex.c stm32h5xx_hal_uart.c
    ../tinyusb/hw/mcu/st/cmsis_device_h5/Source/Templates/: system_stm32h5xx.c
  group drv_l0
    ../tinyusb/hw/bsp/stm32l0/: family.c
    ../tinyusb/hw/mcu/st/cmsis_device_l0/Source/Templates/iar/: startup_stm32l053xx.s
    ../tinyusb/hw/mcu/st/cmsis_device_l0/Source/Templates/iar/linker/: stm32l053xx_flash.icf
    ../tinyusb/hw/mcu/st/stm32l0xx_hal_driver/Src/: stm32l0xx_hal.c stm32l0xx_hal_cortex.c stm32l0xx_hal_gpio.c stm32l0xx_hal_pwr.c stm32l0xx_hal_pwr_ex.c stm32l0xx_hal_rcc.c stm32l0xx_hal_rcc_ex.c stm32l0xx_hal_uart.c
    ../tinyusb/hw/mcu/st/cmsis_device_l0/Source/Templates/: system_stm32l0xx.c
  group drv_lpc55
    ../tinyusb/hw/bsp/lpc55/: family.c
    ../tinyusb/hw/mcu/nxp/mcux-sdk/devices/LPC55S69/drivers/: fsl_clock.c fsl_power.c fsl_reset.c
    ../tinyusb/hw/mcu/nxp/mcux-sdk/drivers/common/: fsl_common.c fsl_common_arm.c
    ../tinyusb/hw/mcu/nxp/mcux-sdk/drivers/flexcomm/: fsl_flexcomm.c fsl_usart.c
    ../tinyusb/hw/mcu/nxp/mcux-sdk/drivers/lpc_gpio/: fsl_gpio.c
    ./: LPC55S69_cm33_core0_flash.icf startup_LPC55S69_cm33_core0.s
    ../tinyusb/hw/mcu/nxp/mcux-sdk/devices/LPC55S69/: system_LPC55S69_cm33_core0.c
  group drv_mimxrt
    $TUSB_DIR$/hw/bsp/imxrt/: family.c
    $TUSB_DIR$/hw/mcu/nxp/mcux-sdk/drivers/common/: fsl_common.c fsl_common_arm.c
    $TUSB_DIR$/hw/mcu/nxp/mcux-sdk/drivers/igpio/: fsl_gpio.c
    $TUSB_DIR$/hw/mcu/nxp/mcux-sdk/drivers/lpuart/: fsl_lpuart.c
    $TUSB_DIR$/hw/mcu/nxp/mcux-sdk/drivers/ocotp/: fsl_ocotp.c
  group drv_mimxrt/rt1176
    $TUSB_DIR$/hw/bsp/imxrt/boards/mimxrt1170_evkb/board/: clock_config.c pin_mux.c
    $TUSB_DIR$/hw/bsp/imxrt/boards/mimxrt1170_evkb/: evkbmimxrt1170_flexspi_nor_config.c
    $TUSB_DIR$/hw/mcu/nxp/mcux-sdk/devices/MIMXRT1176/drivers/: fsl_anatop_ai.c fsl_clock.c fsl_dcdc.c fsl_pmu.c
    $TUSB_DIR$/hw/mcu/nxp/mcux-sdk/devices/MIMXRT1176/xip/: fsl_flexspi_nor_boot.c
    ../mimxrt1170-evkb/: MIMXRT1176xxxxx_cm4_ram.icf MIMXRT1176xxxxx_cm7_flexspi_nor.icf startup_MIMXRT1176_cm4.s startup_MIMXRT1176_cm7.s
    $TUSB_DIR$/hw/mcu/nxp/mcux-sdk/devices/MIMXRT1176/: system_MIMXRT1176_cm4.c system_MIMXRT1176_cm7.c
  group drv_u5
    ../tinyusb/hw/bsp/stm32u5/: family.c
    ../tinyusb/hw/mcu/st/cmsis_device_u5/Source/Templates/iar/: startup_stm32u5a5xx.s
    ../tinyusb/hw/mcu/st/cmsis_device_u5/Source/Templates/iar/linker/: stm32u5a5xx_flash.icf
    ../tinyusb/hw/mcu/st/stm32u5xx_hal_driver/Src/: stm32u5xx_hal.c stm32u5xx_hal_cortex.c stm32u5xx_hal_dcache.c stm32u5xx_hal_gpio.c stm32u5xx_hal_icache.c stm32u5xx_hal_pwr.c stm32u5xx_hal_pwr_ex.c stm32u5xx_hal_rcc.c stm32u5xx_hal_rcc_ex.c stm32u5xx_hal_uart.c
    ../tinyusb/hw/mcu/st/cmsis_device_u5/Source/Templates/: system_stm32u5xx.c
  group example/audio_4_channel_mic
    ../tinyusb/examples/device/audio_4_channel_mic/src/: main.c tusb_config.h usb_descriptors.c usb_descriptors.h
  group example/audio_test_multi_rate
    ../tinyusb/examples/device/audio_test_multi_rate/src/: main.c tusb_config.h usb_descriptors.c usb_descriptors.h
  group example/cdc_dual_ports
    ../tinyusb/examples/device/cdc_dual_ports/src/: main.c tusb_config.h usb_descriptors.c
  group example/cdc_uac2
    ../tinyusb/examples/device/cdc_uac2/src/: cdc_app.c main.c tusb_config.h uac2_app.c usb_descriptors.c
  group example/hid_generic_inout
    ../tinyusb/examples/device/hid_generic_inout/src/: main.c tusb_config.h usb_descriptors.c
  group example/net_lwip_webserver
    ../tinyusb/examples/device/net_lwip_webserver/src/: lwipopts.h main.c tusb_config.h usb_descriptors.c
  group example/uac2_headset
    ../tinyusb/examples/device/uac2_headset/src/: main.c tusb_config.h usb_descriptors.c usb_descriptors.h
  group example/uac2_speaker_fb
    ../tinyusb/examples/device/uac2_speaker_fb/src/: common_types.h main.c quirk_os_guessing.c quirk_os_guessing.h tusb_config.h usb_descriptors.c usb_descriptors.h
  group example/video_capture
    ../tinyusb/examples/device/video_capture/src/: images.h main.c tusb_config.h usb_descriptors.c usb_descriptors.h
  group example/video_capture_2ch
    ../tinyusb/examples/device/video_capture_2ch/src/: images.h main.c tusb_config.h usb_descriptors.c usb_descriptors.h
  group example/webusb_serial
    ../tinyusb/examples/device/webusb_serial/src/: main.c tusb_config.h usb_descriptors.c usb_descriptors.h
  group tinyusb/lib
    ../tinyusb/hw/bsp/: board.c
  group tinyusb/lib/lwip
    ../tinyusb/lib/lwip/src/core/: altcp.c altcp_alloc.c altcp_tcp.c def.c dns.c inet_chksum.c init.c ip.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c
    ../tinyusb/lib/lwip/src/core/ipv4/: autoip.c dhcp.c etharp.c icmp.c igmp.c ip4.c ip4_addr.c ip4_frag.c
    ../tinyusb/lib/lwip/src/core/ipv6/: dhcp6.c ethip6.c icmp6.c inet6.c ip6.c ip6_addr.c ip6_frag.c mld6.c nd6.c
    ../tinyusb/lib/networking/: dhserver.c dnserver.c rndis_reports.c
    ../tinyusb/lib/lwip/src/netif/: ethernet.c slipif.c
    ../tinyusb/lib/lwip/src/apps/http/: fs.c httpd.c
    ../tinyusb/lib/lwip/src/apps/lwiperf/: lwiperf.c
  group tinyusb/lib/SEGGER_RTT/Config
    ../tinyusb/lib/SEGGER_RTT/Config/: SEGGER_RTT_Conf.h
  group tinyusb/lib/SEGGER_RTT/RTT
    ../tinyusb/lib/SEGGER_RTT/RTT/: SEGGER_RTT.c SEGGER_RTT.h SEGGER_RTT_printf.c
  group tinyusb/src
    ../tinyusb/src/: tusb.c tusb.h tusb_option.h
    ../tinyusb/src/common/: tusb_quirk.c
  group tinyusb/src/class/audio
    ../tinyusb/src/class/audio/: audio.h audio_device.c audio_device.h
  group tinyusb/src/class/bth
    ../tinyusb/src/class/bth/: bth_device.c bth_device.h
  group tinyusb/src/class/cdc
    ../tinyusb/src/class/cdc/: cdc.h cdc_device.c cdc_device.h cdc_host.c cdc_host.h cdc_rndis.h cdc_rndis_host.c cdc_rndis_host.h
  group tinyusb/src/class/cdc/serial
    ../tinyusb/src/class/cdc/serial/: ch34x.h cp210x.h ftdi_sio.h
  group tinyusb/src/class/dfu
    ../tinyusb/src/class/dfu/: dfu.h dfu_device.c dfu_device.h dfu_rt_device.c dfu_rt_device.h
  group tinyusb/src/class/hid
    ../tinyusb/src/class/hid/: hid.h hid_device.c hid_device.h hid_host.c hid_host.h
  group tinyusb/src/class/midi
    ../tinyusb/src/class/midi/: midi.h midi_device.c midi_device.h
  group tinyusb/src/class/msc
    ../tinyusb/src/class/msc/: msc.h msc_device.c msc_device.h msc_host.c msc_host.h
  group tinyusb/src/class/net
    ../tinyusb/src/class/net/: ecm_rndis_device.c ncm.h ncm_device.c net_device.h
  group tinyusb/src/class/usbtmc
    ../tinyusb/src/class/usbtmc/: usbtmc.h usbtmc_device.c usbtmc_device.h
  group tinyusb/src/class/vendor
    ../tinyusb/src/class/vendor/: vendor_device.c vendor_device.h vendor_host.c vendor_host.h
  group tinyusb/src/class/video
    ../tinyusb/src/class/video/: video.h video_device.c video_device.h
  group tinyusb/src/common
    ../tinyusb/src/common/: tusb_common.h tusb_compiler.h tusb_debug.h tusb_fifo.c tusb_fifo.h tusb_mcu.h tusb_private.h tusb_types.h tusb_verify.h
  group tinyusb/src/device
    ../tinyusb/src/device/: dcd.h usbd.c usbd.h usbd_control.c usbd_pvt.h
  group tinyusb/src/host
    ../tinyusb/src/host/: hcd.h hub.c hub.h usbh.c usbh.h usbh_pvt.h
  group tinyusb/src/osal
    ../tinyusb/src/osal/: osal.h osal_freertos.h osal_mynewt.h osal_none.h osal_pico.h osal_rtthread.h osal_rtx4.h
  group tinyusb/src/portable/analog/max3421
    ../tinyusb/src/portable/analog/max3421/: hcd_max3421.c
  group tinyusb/src/portable/bridgetek/ft9xx
    ../tinyusb/src/portable/bridgetek/ft9xx/: dcd_ft9xx.c
  group tinyusb/src/portable/chipidea/ci_fs
    ../tinyusb/src/portable/chipidea/ci_fs/: ci_fs_kinetis.h ci_fs_mcx.h ci_fs_type.h dcd_ci_fs.c
  group tinyusb/src/portable/chipidea/ci_hs
    ../tinyusb/src/portable/chipidea/ci_hs/: ci_hs_imxrt.h ci_hs_lpc18_43.h ci_hs_mcx.h ci_hs_type.h dcd_ci_hs.c hcd_ci_hs.c
  group tinyusb/src/portable/dialog/da146xx
    ../tinyusb/src/portable/dialog/da146xx/: dcd_da146xx.c
  group tinyusb/src/portable/ehci
    ../tinyusb/src/portable/ehci/: ehci.c ehci.h ehci_api.h
  group tinyusb/src/portable/mentor/musb
    ../tinyusb/src/portable/mentor/musb/: dcd_musb.c hcd_musb.c musb_msp432e.h musb_tm4c.h musb_type.h
  group tinyusb/src/portable/microchip/pic
    ../tinyusb/src/portable/microchip/pic/: dcd_pic.c
  group tinyusb/src/portable/microchip/pic32mz
    ../tinyusb/src/portable/microchip/pic32mz/: dcd_pic32mz.c usbhs_registers.h
  group tinyusb/src/portable/microchip/samd
    ../tinyusb/src/portable/microchip/samd/: dcd_samd.c
  group tinyusb/src/portable/microchip/samg
    ../tinyusb/src/portable/microchip/samg/: dcd_samg.c
  group tinyusb/src/portable/microchip/samx7x
    ../tinyusb/src/portable/microchip/samx7x/: common_usb_regs.h dcd_samx7x.c
  group tinyusb/src/portable/mindmotion/mm32
    ../tinyusb/src/portable/mindmotion/mm32/: dcd_mm32f327x_otg.c
  group tinyusb/src/portable/nordic/nrf5x
    ../tinyusb/src/portable/nordic/nrf5x/: dcd_nrf5x.c
  group tinyusb/src/portable/nuvoton/nuc120
    ../tinyusb/src/portable/nuvoton/nuc120/: dcd_nuc120.c
  group tinyusb/src/portable/nuvoton/nuc121
    ../tinyusb/src/portable/nuvoton/nuc121/: dcd_nuc121.c
  group tinyusb/src/portable/nuvoton/nuc505
    ../tinyusb/src/portable/nuvoton/nuc505/: dcd_nuc505.c
  group tinyusb/src/portable/nxp/khci
    ../tinyusb/src/portable/nxp/khci/: dcd_khci.c hcd_khci.c
  group tinyusb/src/portable/nxp/lpc17_40
    ../tinyusb/src/portable/nxp/lpc17_40/: dcd_lpc17_40.c dcd_lpc17_40.h hcd_lpc17_40.c
  group tinyusb/src/portable/nxp/lpc_ip3511
    ../tinyusb/src/portable/nxp/lpc_ip3511/: dcd_lpc_ip3511.c
  group tinyusb/src/portable/ohci
    ../tinyusb/src/portable/ohci/: ohci.c ohci.h
  group tinyusb/src/portable/raspberrypi/pio_usb
    ../tinyusb/src/portable/raspberrypi/pio_usb/: dcd_pio_usb.c hcd_pio_usb.c
  group tinyusb/src/portable/raspberrypi/rp2040
    ../tinyusb/src/portable/raspberrypi/rp2040/: dcd_rp2040.c hcd_rp2040.c rp2040_usb.c rp2040_usb.h
  group tinyusb/src/portable/renesas/rusb2
    ../tinyusb/src/portable/renesas/rusb2/: dcd_rusb2.c hcd_rusb2.c rusb2_common.c rusb2_ra.h rusb2_rx.h rusb2_type.h
  group tinyusb/src/portable/sony/cxd56
    ../tinyusb/src/portable/sony/cxd56/: dcd_cxd56.c
  group tinyusb/src/portable/st/stm32_fsdev
    ../tinyusb/src/portable/st/stm32_fsdev/: dcd_stm32_fsdev.c dcd_stm32_fsdev.h
  group tinyusb/src/portable/st/typec
    ../tinyusb/src/portable/st/typec/: typec_stm32.c
  group tinyusb/src/portable/sunxi
    ../tinyusb/src/portable/sunxi/: dcd_sunxi_musb.c musb_def.h
  group tinyusb/src/portable/synopsys/dwc2
    ../tinyusb/src/portable/synopsys/dwc2/: dcd_dwc2.c dwc2_bcm.h dwc2_efm32.h dwc2_esp32.h dwc2_gd32.h dwc2_stm32.h dwc2_type.h dwc2_xmc.h
  group tinyusb/src/portable/ti/msp430x5xx
    ../tinyusb/src/portable/ti/msp430x5xx/: dcd_msp430x5xx.c
  group tinyusb/src/portable/valentyusb/eptri
    ../tinyusb/src/portable/valentyusb/eptri/: dcd_eptri.c dcd_eptri.h
  group tinyusb/src/portable/wch
    ../tinyusb/src/portable/wch/: ch32_usbhs_reg.h dcd_ch32_usbhs.c
  group tinyusb/src/typec
    ../tinyusb/src/typec/: pd_types.h tcd.h usbc.c usbc.h
